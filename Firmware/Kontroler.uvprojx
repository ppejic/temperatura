# Keil uVision project Kontroler.uvprojx, settings and files
target Obrovac-Temperatura (ARM-ADS)
  device: LPC11U14FBD48/201 NXP
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x1000) IRAM2(0x20004000,0x0800) CPUTYPE("Cortex-M0+") CLOCK(50000000) ELITTLE
  output: Kontroler
  c flags: Optim=1
  c define: CORE_M0
  c misc: --diag_suppress 111
  c include: .\LIB\INCLUDE
  asm define: NO_CRP
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  memory RVCT10: RAM 0x20004000 size 0x800
  group SRC
    ./: main.c ads1248.c
    ./LIB/INCLUDE/: ads1248.h main.h
  group USB
    ./: cdc_desc.c cdc_vcom.c cdc_usb.c
    ./LIB/INCLUDE/: cdc_usb.h
  group LIB
    ./LIB/: chip_11uxx_lib.lib usbd_11uxx_lib.lib
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/3.20.4/CMSIS_RTX/Lib/ARM/: RTX_CM0.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    RTE/Device/LPC11U14FBD48_201/: startup_LPC11Uxx.s system_LPC11Uxx.c
software components: CMSIS:CORE 3.20.0, CMSIS:RTOS:Keil RTX 4.74.0, Device:Startup 1.0.0
